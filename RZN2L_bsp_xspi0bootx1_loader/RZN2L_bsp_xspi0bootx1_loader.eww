<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RZN2L_bsp_xspi0bootx1_loader.ewp</path>
    </project>
    <batchBuild/>
</workspace>
